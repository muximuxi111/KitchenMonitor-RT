# Keil uVision project 11.10_LVGL.uvprojx, settings and files
target 11.10_LVGL (6220000::V6.22::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 11_10_LVGL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../LVGL_CUT;../LVGL_CUT/src;../LVGL_CUT/porting;../LVGL_CUT/UI;../LVGL_CUT/UI/screens;../LVGL_CUT/UI/fonts;../LVGL_CUT/UI/components
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: pic.c ziku.c bsp_ft6336.c bsp_ili9341_4line.c sensor.c wifi.c adc_monitor.c system_state.c alarm.c key.c task_state.c ui_bind.c alarm_log.c main.c gpio.c freertos.c adc.c dma.c i2c.c spi.c tim.c usart.c wwdg.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group LVGL_port
    ../LVGL_CUT/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL_conf
    ../LVGL_CUT/: lv_conf.h lvgl.h
  group LVGL_src
    ../LVGL_CUT/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL_CUT/src/draw/arm2d/: lv_gpu_arm2d.c
    ../LVGL_CUT/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../LVGL_CUT/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../LVGL_CUT/src/draw/renesas/: lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c
    ../LVGL_CUT/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../LVGL_CUT/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../LVGL_CUT/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL_CUT/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../LVGL_CUT/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL_CUT/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../LVGL_CUT/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL_CUT/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL_CUT/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../LVGL_CUT/src/extra/: lv_extra.c lv_extra.h
    ../LVGL_CUT/src/extra/layouts/flex/: lv_flex.c
    ../LVGL_CUT/src/extra/layouts/grid/: lv_grid.c
    ../LVGL_CUT/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL_CUT/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL_CUT/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL_CUT/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL_CUT/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL_CUT/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL_CUT/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL_CUT/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL_CUT/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL_CUT/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../LVGL_CUT/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL_CUT/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL_CUT/src/extra/others/ime/: lv_ime_pinyin.c
    ../LVGL_CUT/src/extra/others/imgfont/: lv_imgfont.c
    ../LVGL_CUT/src/extra/others/monkey/: lv_monkey.c
    ../LVGL_CUT/src/extra/others/msg/: lv_msg.c
    ../LVGL_CUT/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL_CUT/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL_CUT/src/extra/themes/default/: lv_theme_default.c
    ../LVGL_CUT/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL_CUT/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL_CUT/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL_CUT/src/extra/widgets/chart/: lv_chart.c
    ../LVGL_CUT/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL_CUT/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL_CUT/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL_CUT/src/extra/widgets/led/: lv_led.c
    ../LVGL_CUT/src/extra/widgets/list/: lv_list.c
    ../LVGL_CUT/src/extra/widgets/menu/: lv_menu.c
    ../LVGL_CUT/src/extra/widgets/meter/: lv_meter.c
    ../LVGL_CUT/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL_CUT/src/extra/widgets/span/: lv_span.c
    ../LVGL_CUT/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL_CUT/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL_CUT/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL_CUT/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL_CUT/src/extra/widgets/win/: lv_win.c
  group LVGL_ui
    ../LVGL_CUT/UI/components/: ui_comp_hook.c
    ../LVGL_CUT/UI/: ui.c ui.h ui_events.h ui_helpers.c ui_helpers.h
    ../LVGL_CUT/UI/images/: ui_img_____copy_png.c ui_img____png.c ui_img_led__png.c ui_img________png.c ui_img_______png.c ui_img_led_____png.c ui_img_____png.c ui_img___1_png.c ui_img___2_png.c ui_img___3_png.c ui_img___png.c ui_img_normal_png.c ui_img_alarm_png.c ui_img_warning_png.c ui_img___________png.c ui_img______1__png.c ui_img______png.c ui_img_____2__png.c ui_img_____3__png.c ui_img_791845303357734700.c ui_img_12450877827944176941.c ui_img_17253922239053792595.c ui_img_17974314145315461261.c ui_img_2000032059467068984.c ui_img_4659201705655773562.c ui_img_6001231565455461767.c ui_img_7757037498986594281.c ui_img_wifi__1__png.c
    ../LVGL_CUT/UI/fonts/: ui_font_KaiTi.c
    ../LVGL_CUT/UI/screens/: ui_Home.c ui_Home.h ui_Setting.c ui_Setting.h ui_Warning.c ui_Warning.h ui_WIFI_Screen.c ui_WIFI_Screen.h
software components: CMSIS:CORE 6.1.0
