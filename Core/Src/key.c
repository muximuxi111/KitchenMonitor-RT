#include "key.h"
#include "task_state.h"


/* ==========================================================================
 * 三个按键的扫描
 * --------------------------------------------------------------------------
 * 硬件：
 *     KEY1 = PC9   功能：切换屏幕（主页 → 设置 → 报警 → 主页）
 *     KEY2 = PC8   功能：直接进入设置页
 *     KEY3 = PC5   功能：报警消音（翻转事件位 EVT_MUTED）
 *
 * 按键接法：一端接单片机引脚，一端接 GND，引脚上拉。
 *     松开 = 引脚读到高电平 1
 *     按下 = 引脚读到低电平 0
 *
 * 怎么调用的：
 *     wait_event 任务（freertos.c）的循环里每 10ms 调一次 Key_Scan()，
 *     循环末尾本来就有 osDelay(10)，所以这里不需要任何定时器，
 *     也不需要任何延时函数。
 *
 * 消抖思路（三个键完全一样，只是动作不同）：
 *     每 10ms 读一次电平，也就是「采样一次」。
 *     刚按下的一瞬间电平会抖动，可能读到 0-1-0-0-1-0，所以不能读一次就动作。
 *
 *     每个键准备两个变量：
 *         cnt   : 已经连续读到低电平的次数
 *         flag  : 这一次按下是不是已经执行过动作了（防止按住不放一直触发）
 *
 *     判断流程：
 *         1) 读到低电平（按下）→ cnt 加 1，最多加到 3（3 次 = 30ms）
 *         2) cnt 加到 3 并且 flag 还是 0 → 说明按稳了，把 flag 置 1，执行动作
 *         3) 读到高电平（松手）→ cnt 和 flag 都清 0，准备下一次按下
 *
 * 为什么按键1、按键2 不在这里直接切屏：
 *     LVGL 不是线程安全的。这个扫描运行在 wait_event 任务里，
 *     而界面刷新 lv_timer_handler() 运行在 LCD 任务里。
 *     如果这里直接去切屏，就会和 LCD 任务同时操作 LVGL，
 *     轻则画面花屏，重则卡死在 LVGL 的断言里。
 *
 *     所以这里只做两件事：
 *         - 按键1 按下：把 g_key1_request 置 1（就是"举手说我想切屏"）
 *         - 按键2 按下：把 g_key2_request 置 1
 *     真正切屏由 LCD 任务里的 Ui_Key_Task() 去做（在 ui_bind.c 里），
 *     做完把标志清 0。
 *
 *     按键3 不用绕，因为它只改事件位，不碰 LVGL。
 * ========================================================================== */


/* 按键1、按键2 的请求标志。
   扫描函数里置 1，LCD 任务里读走并清 0。
   一个字节的读写是原子的，不会读一半，所以不用加锁。 */
volatile uint8_t g_key1_request = 0;
volatile uint8_t g_key2_request = 0;


/* ==========================================================================
 * 每个按键各自的消抖状态
 * --------------------------------------------------------------------------
 * 两个变量就够：
 *     cnt   连续读到低电平的次数
 *     flag  这次按下是否已经执行过动作
 *
 * 三个键各有一个这样的结构体（写在 KeyX_Scan 里的 static 变量），
 * 互不干扰。
 * ========================================================================== */
typedef struct
{
    uint8_t cnt;    /* 连续读到低电平的次数 */
    uint8_t flag;   /* 本次按下是否已经执行过动作 */
} KeyState;


/* ==========================================================================
 * 消抖：三个键统一走这一个函数
 * --------------------------------------------------------------------------
 * 参数：
 *     key   这个键自己的状态（上面那个结构体）
 *     port  引脚所在的端口，例如 KEY1_GPIO_Port
 *     pin   引脚号，例如 KEY1_Pin
 *
 * 返回值：
 *     1 = 这一下按稳了，请执行动作（一次按下只会返回一次 1）
 *     0 = 什么都没发生，不用管
 *
 * 这个函数不做任何延时，进来读一次引脚就出去了，
 * 所以它不会卡住任务，也不会让 CPU 空转等待。
 * ========================================================================== */
static uint8_t Key_Debounce(KeyState *key, GPIO_TypeDef *port, uint16_t pin)
{
    if (HAL_GPIO_ReadPin(port, pin) == GPIO_PIN_RESET)   /* 读到低电平 = 按下 */
    {
        if (key->cnt < 3)
        {
            key->cnt++;              /* 数到 3 就是稳定 3×10ms = 30ms */
        }

        if (key->cnt == 3 && key->flag == 0)
        {
            key->flag = 1;           /* 只处理一次，按住不放不重复 */
            return 1;                /* 告诉外面：可以动作了 */
        }
    }
    else                         /* 读到高电平 = 松手 */
    {
        key->cnt  = 0;               /* 重新开始数 */
        key->flag = 0;               /* 允许下一次按下再触发 */
    }

    return 0;                        /* 还在抖，或者根本没按下 */
}


/* ==========================================================================
 * KEY1：PC9，按下后请求切换屏幕
 * ========================================================================== */
void Key1_Scan(void)
{
    static KeyState key1 = {0, 0};   /* 按键1 自己的消抖状态 */

    /* 消抖函数说"没按稳"就直接回去，下面三行都不执行 */
    if (Key_Debounce(&key1, KEY1_GPIO_Port, KEY1_Pin) == 0)
    {
        return;
    }

    g_key1_request = 1;              /* 举手：请 LCD 任务切一次屏 */
}


/* ==========================================================================
 * KEY2：PC8，按下后请求进入设置页
 * ========================================================================== */
void Key2_Scan(void)
{
    static KeyState key2 = {0, 0};

    if (Key_Debounce(&key2, KEY2_GPIO_Port, KEY2_Pin) == 0)
    {
        return;
    }

    g_key2_request = 1;              /* 举手：请 LCD 任务进设置页 */
}


/* ==========================================================================
 * KEY3 的动作：消音
 * --------------------------------------------------------------------------
 * 规则沿用基础项目：
 *     - 只有在报警时才允许消音，也就是只有火焰报警(EVT_FIRE)
 *       或者电压电流异常(EVT_ELEC)时才管事；
 *     - 每按一次翻转一次 EVT_MUTED：
 *           原来没静音 → 置位 EVT_MUTED   → 蜂鸣器停
 *           原来已静音 → 清除 EVT_MUTED   → 蜂鸣器重新响
 *     - LED 不受静音影响，报警时该怎么亮还怎么亮。
 *
 * 这个函数只做"动作"，不负责消抖，消抖在 Key3_Scan() 里。
 * ========================================================================== */
void Mute_Key3(void)
{
    uint32_t flags;

    flags = osEventFlagsGet(myEvent01Handle);   /* 读当前所有事件位 */

    /* 没有报警就不该消音，直接返回 */
    if ((flags & (EVT_FIRE | EVT_ELEC)) == 0)
    {
        return;
    }

    /* 已经静音了，那就取消静音 */
    if (flags & EVT_MUTED)
    {
        osEventFlagsClear(myEvent01Handle, EVT_MUTED);
    }
    else
    {
        osEventFlagsSet(myEvent01Handle, EVT_MUTED);   /* 还没静音，那就静音 */
    }
}


/* ==========================================================================
 * KEY3：PC5，消抖和上面两个键一模一样，只是动作换成调 Mute_Key3()
 * ========================================================================== */
void Key3_Scan(void)
{
    static KeyState key3 = {0, 0};

    if (Key_Debounce(&key3, KEY3_GPIO_Port, KEY3_Pin) == 0)
    {
        return;
    }

    Mute_Key3();                     /* 直接在这里动作，因为改事件位不需要碰 LVGL */
}


/* ==========================================================================
 * 一次扫描三个键
 * 由 wait_event 任务开启软件定时器，每10ms调用一次KeyTimer_Callback扫描三个按键的状态
 * ========================================================================== */
void Key_Scan(void)
{
    Key1_Scan();
    Key2_Scan();
    Key3_Scan();
}
